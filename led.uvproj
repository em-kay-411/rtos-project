# Keil uVision project led.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\ScatterFile.sct
  group ucos-II
    ./uCOS-II/: cpu_a.s lib_mem.c lib_str.c os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c bsp.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group app
    ./app/: adc.c app.c func.h init.s kbd.c lcd.c LED.c Startup.s UART.c vectors.s
  group include
    ./include/: app_cfg.h bsp.h cpu.h cpu_def.h includes.h iolpc2148.h lib_def.h lib_mem.h lib_str.h os_cfg.h os_cpu.h ucos_ii.h
